# Keil uVision project lab_env.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_exec
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: ..\CORTEX_STM32F103_Keil;.\STM32F10xFWLib\inc;.\FreeRTOS\inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./: STM32F10x.s
    ./STM32F10xFWLib/src/: stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c cortexm3_macro_rvds.s
  group Application Files
    ./: main.c setup.c pin_listener.c position_tracker.c motor.c planner.c safety.c
  group FreeRTOS files
    ./FreeRTOS/src/: heap_2.c list.c port.c queue.c tasks.c serial.c
